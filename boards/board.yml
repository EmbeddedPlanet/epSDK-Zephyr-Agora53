## boards/board.yml
```yaml
board:
  name: agora
  full_name: agora
  vendor: ep
  socs:
  - name: 'nrf5340'
    variants:
    - name: 'ns'
      cpucluster: 'cpuapp'
```
